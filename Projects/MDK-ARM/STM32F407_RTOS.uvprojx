# Keil uVision project STM32F407_RTOS.uvprojx, settings and files
target STM32F407ZGT6 (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407_RTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Drivers/BSP
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/SRAM/: sram.c
    ../../Drivers/BSP/TIMER/: atim.c btim.c gtim.c
  group Drivers/HALLIB
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_fsmc.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/SMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/SMSIS/ARM
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Middlewares/MALLOC
    ../../Middlewares/MALLOC/: malloc.c
  group Middlewares/XMRAM
    F:/Keil/01_STM32F407_RTOS/Middlewares/XMRAM/: XMRAM.lib
  group Middlewares/FreeRTOS
    ../../Middlewares/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS/portable/ARMClang
    ../../Middlewares/FreeRTOS/Source/portable/ARMClang/ARM_CM4F/: port.c
  group Middlewares/FreeRTOS/portable/MemMang
    ../../Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/LVGL/porting
    ../../Middlewares/LVGL/GUI/lvgl/examples/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c lv_port_lcd_stm32_template.c
  group Middlewares/LVGL/src
    ../../Middlewares/LVGL/GUI/lvgl/src/: lv_init.c
  group Middlewares/LVGL/src/core
    ../../Middlewares/LVGL/GUI/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
  group Middlewares/LVGL/src/display
    ../../Middlewares/LVGL/GUI/lvgl/src/display/: lv_display.c
  group Middlewares/LVGL/src/draw
    ../../Middlewares/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../../Middlewares/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    ../../Middlewares/LVGL/GUI/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c
    ../../Middlewares/LVGL/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c
  group Middlewares/LVGL/src/drivers
    ../../Middlewares/LVGL/GUI/lvgl/src/drivers/display/drm/: lv_linux_drm.c
    ../../Middlewares/LVGL/GUI/lvgl/src/drivers/display/fb/: lv_linux_fbdev.c
    ../../Middlewares/LVGL/GUI/lvgl/src/drivers/display/ili9341/: lv_ili9341.c
    ../../Middlewares/LVGL/GUI/lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    ../../Middlewares/LVGL/GUI/lvgl/src/drivers/display/st7735/: lv_st7735.c
    ../../Middlewares/LVGL/GUI/lvgl/src/drivers/display/st7789/: lv_st7789.c
    ../../Middlewares/LVGL/GUI/lvgl/src/drivers/display/st7796/: lv_st7796.c
    ../../Middlewares/LVGL/GUI/lvgl/src/drivers/evdev/: lv_evdev.c
    ../../Middlewares/LVGL/GUI/lvgl/src/drivers/libinput/: lv_libinput.c lv_xkb.c
    ../../Middlewares/LVGL/GUI/lvgl/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
    ../../Middlewares/LVGL/GUI/lvgl/src/drivers/sdl/: lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_window.c
  group Middlewares/LVGL/src/font
    ../../Middlewares/LVGL/GUI/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group Middlewares/LVGL/src/indev
    ../../Middlewares/LVGL/GUI/lvgl/src/indev/: lv_indev.c lv_indev_scroll.c
  group Middlewares/LVGL/src/layouts
    ../../Middlewares/LVGL/GUI/lvgl/src/layouts/: lv_layout.c
    ../../Middlewares/LVGL/GUI/lvgl/src/layouts/flex/: lv_flex.c
    ../../Middlewares/LVGL/GUI/lvgl/src/layouts/grid/: lv_grid.c
  group Middlewares/LVGL/src/libs
    ../../Middlewares/LVGL/GUI/lvgl/src/libs/barcode/: lv_barcode.c
    ../../Middlewares/LVGL/GUI/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../../Middlewares/LVGL/GUI/lvgl/src/libs/bmp/: lv_bmp.c
    ../../Middlewares/LVGL/GUI/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../../Middlewares/LVGL/GUI/lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../../Middlewares/LVGL/GUI/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../Middlewares/LVGL/GUI/lvgl/src/libs/gif/: lv_gif.c
    ../../Middlewares/LVGL/GUI/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ../../Middlewares/LVGL/GUI/lvgl/src/libs/libpng/: lv_libpng.c
    ../../Middlewares/LVGL/GUI/lvgl/src/libs/lodepng/: lv_lodepng.c lv_lodepng.c
    ../../Middlewares/LVGL/GUI/lvgl/src/libs/qrcode/: lv_qrcode.c
    ../../Middlewares/LVGL/GUI/lvgl/src/libs/rle/: lv_rle.c
    ../../Middlewares/LVGL/GUI/lvgl/src/libs/rlottie/: lv_rlottie.c
    ../../Middlewares/LVGL/GUI/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../../Middlewares/LVGL/GUI/lvgl/src/libs/tjpgd/: lv_tjpgd.c
  group Middlewares/LVGL/src/misc
    ../../Middlewares/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_utils.c
    ../../Middlewares/LVGL/GUI/lvgl/src/misc/cache/: _lv_cache_lru_rb.c lv_cache.c lv_cache_entry.c lv_image_cache.c
  group Middlewares/LVGL/src/osal
    ../../Middlewares/LVGL/GUI/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_windows.c
  group Middlewares/LVGL/src/others
    ../../Middlewares/LVGL/GUI/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../../Middlewares/LVGL/GUI/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../Middlewares/LVGL/GUI/lvgl/src/others/gridnav/: lv_gridnav.c
    ../../Middlewares/LVGL/GUI/lvgl/src/others/ime/: lv_ime_pinyin.c
    ../../Middlewares/LVGL/GUI/lvgl/src/others/imgfont/: lv_imgfont.c
    ../../Middlewares/LVGL/GUI/lvgl/src/others/monkey/: lv_monkey.c
    ../../Middlewares/LVGL/GUI/lvgl/src/others/observer/: lv_observer.c
    ../../Middlewares/LVGL/GUI/lvgl/src/others/snapshot/: lv_snapshot.c
    ../../Middlewares/LVGL/GUI/lvgl/src/others/sysmon/: lv_sysmon.c
    ../../Middlewares/LVGL/GUI/lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c
  group Middlewares/LVGL/src/stdlib
    ../../Middlewares/LVGL/GUI/lvgl/src/stdlib/: lv_mem.c
    ../../Middlewares/LVGL/GUI/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../../Middlewares/LVGL/GUI/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../../Middlewares/LVGL/GUI/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../../Middlewares/LVGL/GUI/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
  group Middlewares/LVGL/src/themes
    ../../Middlewares/LVGL/GUI/lvgl/src/themes/: lv_theme.c
    ../../Middlewares/LVGL/GUI/lvgl/src/themes/default/: lv_theme_default.c
    ../../Middlewares/LVGL/GUI/lvgl/src/themes/mono/: lv_theme_mono.c
    ../../Middlewares/LVGL/GUI/lvgl/src/themes/simple/: lv_theme_simple.c
  group Middlewares/LVGL/src/tick
    ../../Middlewares/LVGL/GUI/lvgl/src/tick/: lv_tick.c
  group Middlewares/LVGL/src/widgets
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/animimage/: lv_animimage.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/arc/: lv_arc.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/bar/: lv_bar.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/button/: lv_button.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/canvas/: lv_canvas.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/chart/: lv_chart.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/image/: lv_image.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/label/: lv_label.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/led/: lv_led.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/line/: lv_line.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/list/: lv_list.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/menu/: lv_menu.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/roller/: lv_roller.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/scale/: lv_scale.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/slider/: lv_slider.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/span/: lv_span.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/spinner/: lv_spinner.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/switch/: lv_switch.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/table/: lv_table.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/tabview/: lv_tabview.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/textarea/: lv_textarea.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/tileview/: lv_tileview.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/win/: lv_win.c
